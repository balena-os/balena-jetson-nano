# Flash to internal eMMC - kernel enumerates this, when SD card is in, as mmcblk0
INTERNAL_DEVICE_KERNEL_tegra186 = "mmcblk0"
INTERNAL_DEVICE_KERNEL_jetson-tx1 = "mmcblk0"
